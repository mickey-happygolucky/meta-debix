SRC_URI += "file://0001-dtb-add-dts-file-for-DEBIX-model-A.patch;subdir=git"

FILESEXTRAPATHS:prepend := "${THISDIR}/${PN}:"
