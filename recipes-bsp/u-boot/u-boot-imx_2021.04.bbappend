UBOOT_SRC_debix-a ?= "git://github.com/debix-tech/uboot.git;protocol=https"
SRCREV_debix-a = "1a87b972fac74699482e2dce2023b66358d8c4f5"
